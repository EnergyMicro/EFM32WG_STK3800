# Keil uVision project mpu.uvproj, settings and files
target mpu (ARM-ADS)
  device: EFM32WG990F256 Energy Micro
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(48000000) CPUTYPE("Cortex-M4") FPU2
  output: mpu
  AfterMake: fromelf.exe --bin --output obj\mpu.bin obj\mpu.axf
  c flags: Optim=1 oTime=1
  c define: EFM32WG990F256
  c misc: --c99
  c include: ..\;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\Device\EnergyMicro\EFM32WG\Include;..\..\..\..\..\emlib\inc;..\..\..\..\common\drivers;..\..\..\..\common\bsp;..\..\..\config
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../../../../../Device/EnergyMicro/EFM32WG/Source/ARM/: startup_efm32wg.s
    ../../../../../Device/EnergyMicro/EFM32WG/Source/: system_efm32wg.c
  group Drivers
    ../../../../common/drivers/: rtcdrv.c segmentlcd.c
  group BSP
    ../../../../common/bsp/: bsp_trace.c
  group emlib
    ../../../../../emlib/src/: em_cmu.c em_emu.c em_gpio.c em_lcd.c em_mpu.c em_rtc.c em_system.c
  group Source
    ../: mpu.c
