# Keil uVision project touch.uvproj, settings and files
target touch (ARM-ADS)
  device: EFM32WG990F256 Energy Micro
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(48000000) CPUTYPE("Cortex-M4") FPU2
  output: touch
  AfterMake: fromelf.exe --bin --output obj\touch.bin obj\touch.axf
  c flags: Optim=4 oTime=1
  c define: EFM32WG990F256
  c misc: --c99
  c include: ..\;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\Device\EnergyMicro\EFM32WG\Include;..\..\..\..\..\emlib\inc;..\..\..\..\common\drivers;..\..\..\..\common\bsp;..\..\..\config
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../../../../../Device/EnergyMicro/EFM32WG/Source/ARM/: startup_efm32wg.s
    ../../../../../Device/EnergyMicro/EFM32WG/Source/: system_efm32wg.c
  group bsp
    ../../../../common/bsp/: bsp_trace.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_acmp.c em_cmu.c em_emu.c em_gpio.c em_int.c em_lesense.c em_rtc.c em_system.c em_lcd.c em_vcmp.c
  group Drivers
    ../../../../common/drivers/: rtcdrv.c vddcheck.c segmentlcd.c caplesense.c
  group Source
    ../: touchdemo.c
